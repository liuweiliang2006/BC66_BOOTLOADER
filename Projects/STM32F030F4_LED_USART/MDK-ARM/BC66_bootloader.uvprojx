# Keil uVision project BC66_bootloader.uvprojx, settings and files
target STM32F030F4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0308_Discovery +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030xC,
  c include: .\..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\..\..\..\Libraries\CMSIS\Include;.\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\..\..\..\Utilities\STM32F0308-Discovery;..\..\..\SYSTEM\sys;..\..\..\HARDWARE\spiflash;..\..\..\HARDWARE\LED;..\..\..\BSP;..\..\..\HARDWARE\beep;..\..\..\HARDWARE\delay;..\..\..\HARDWARE\md5;..\..\..\HARDWARE\sim900a;..\..\..\HARDWARE\STMFLASH;..\..\..\HARDWARE\fram;..\..\..\HARDWARE\usart;..\..\..\IAP;..\..\..\HARDWARE\moto;..\..\..\UARTUPDATA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7fff
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ./../: system_stm32f0xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030xc.s
  group BSP
    ../../../HARDWARE/beep/: beep.c
    ../../../HARDWARE/delay/: delay.c
    ../../../HARDWARE/LED/: led.c
    ../../../HARDWARE/md5/: md5.c
    ../../../HARDWARE/sim900a/: sim900a.c
    ../../../HARDWARE/STMFLASH/: stmflash.c
    ../../../HARDWARE/usart/: usart.c
    ../../../HARDWARE/spiflash/: spi_flash.c
    ../../../HARDWARE/fram/: MB85RS16A.c
    ../../../HARDWARE/moto/: motor.c
    ../../../BSP/: ATCmdAnalyse.c
  group STM32F0xx_StdPeriph_Driver
    ./../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ./../: main.c stm32f0xx_it.c
  group SYS
    ../../../SYSTEM/sys/: sys.c
  group IAP
    ../../../IAP/: iap.c
  group UARTUPDATA
    ../../../UARTUPDATA/: common.c flash_if.c menu.c ymodem.c
